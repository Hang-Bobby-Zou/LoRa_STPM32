# Keil uVision project LoRa-STPM32.uvprojx, settings and files
target LoRa-STPM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L433CCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: LoRa-STPM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx,LORA_KIWI_MODE
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/LoRaMAC/boards;../Drivers/LoRaMAC/mac;../Drivers/LoRaMAC/radio;../Drivers/LoRaMAC/system;../Drivers/LoRaMAC/system/crypto;../Drivers/LoRaMAC/peripherals;../Drivers/LoRaMAC/radio/sx1276
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l433xx.s
  group Application/User
    ../Src/: RedundantCode.c ext_flash.c ext_flash_tb.c STPM32.c LoRa.c HAL_LoRaMAC.c HAL_gpio.c HAL_spi.c main.c freertos.c tim.c usart.c usb.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Driver/LoRaMAC
    ../Drivers/LoRaMAC/mac/: LoRaMac.c LoRaMacCrypto.c
    ../Drivers/LoRaMAC/mac/region/: Region.c RegionCN470.c RegionCommon.c
    ../Drivers/LoRaMAC/radio/sx1276/: sx1276.c
    ../Drivers/LoRaMAC/system/: delay.c fifo.c gpio.c timer.c
    ../Drivers/LoRaMAC/system/crypto/: aes.c cmac.c
    ../Drivers/LoRaMAC/boards/LoRaMote/: board.c delay-board.c gpio-board.c rtc-board.c spi-board.c uart-board.c
    ../Drivers/LoRaMAC/boards/SensorNode/: sx1276-board.c
    ../Drivers/LoRaMAC/boards/mcu/: utilities.c
software components: CMSIS:CORE 4.3.0
